Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 10142021 - BOMBA 89-62 TJM 2 20,0CV T 4V IR3.IFC
Time: 2024-02-16T13:24:20
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 12453152-3D.IGS<1>[1] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 12453152-3D.IGS<1>[2] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 12453152-3D.IGS<1>[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 12453152-3D.IGS<1>[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: CARCAÇA 89-62 2.1-2'' X 2'' - 60380001_Default (2)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
CARCAÇA 89-62 2.1-2'' X 2'' - 60380001_Default | Ferro fundido cinza (SN)
CARCAÇA 89-62 2.1-2'' X 2'' - 60380001_Default | 0

# IfcBuildingElementProxy: INTERMEDIARIA 89-62 FC184 - 60460003_Default (2)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
INTERMEDIARIA 89-62 FC184 - 60460003_Default | Steel
INTERMEDIARIA 89-62 FC184 - 60460003_Default | 0

# IfcBuildingElementProxy: PARAFUSO SEXTAVADO UNC 1-2'' x 1'' SALT SPRAY 96h - 60700041_Default (8)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
4 x PARAFUSO SEXTAVADO UNC 1-2'' x 1'' SALT SPRAY 96h - 60700041_Default | Steel
4 x PARAFUSO SEXTAVADO UNC 1-2'' x 1'' SALT SPRAY 96h - 60700041_Default | 0

# IfcBuildingElementProxy: PARAFUSO SEXTAVADO UNC 3-8'' x 1'' SALT SPRAY 96h - 60700183 (16)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: PLUG DE ESCORVA LATÃO 3-8'' - 60550166_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: W22_JM_JP_PUMPS_FRONT_COVER_FLANGE_FC_NEMA_160.IGS
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: W22_JM_JP_PUMPS_SHAFT_JM_160.IGS
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: W22_TERMINAL_BOX_160.IGS
In: Default Storey
PredefinedType: ELEMENT; Material: 0
